PACKAGECONFIG:append = " \
	wayland-drm-egl-server-buffer \
"

PACKAGECONFIG:remove = " \
	xcomposite-glx \
"
