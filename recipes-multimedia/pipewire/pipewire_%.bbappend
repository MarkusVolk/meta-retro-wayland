RRECOMMENDS:${PN} += " \
	alsa-utils \
	pipewire-alsa \
	pipewire-alsa-card-profile \
	pipewire-pulse \
	pipewire-spa-plugins-meta \
	pipewire-modules-meta \
"
