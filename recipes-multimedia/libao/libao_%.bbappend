PACKAGECONFIG_append = " pulseaudio"

