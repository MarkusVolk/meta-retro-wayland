RRECOMMENDS_${PN} += " \
	alsa-utils \
	pulseaudio-misc \
	pulseaudio-pa-info \
	pulseaudio-server \
	pulseaudio-module-allow-passthrough \
	pulseaudio-module-alsa-card \
	pulseaudio-module-alsa-sink \
	pulseaudio-module-alsa-source \
	pulseaudio-module-always-sink \
	pulseaudio-module-augment-properties \
	pulseaudio-module-bluetooth-policy \
	pulseaudio-module-bluez5-device \
	pulseaudio-module-bluez5-discover \
	pulseaudio-module-card-restore \
	pulseaudio-module-default-device-restore \
	pulseaudio-module-detect \
	pulseaudio-module-device-restore \
	pulseaudio-module-filter-apply \
	pulseaudio-module-filter-heuristics \
	pulseaudio-module-intended-roles \
	pulseaudio-module-native-protocol-tcp \
	pulseaudio-module-native-protocol-unix \
	pulseaudio-module-null-sink \
	pulseaudio-module-position-event-sounds \
	pulseaudio-module-role-cork \
	pulseaudio-module-stream-restore \
	pulseaudio-module-suspend-on-idle \
	pulseaudio-module-switch-on-connect \
	pulseaudio-module-switch-on-port-available \
	pulseaudio-module-systemd-login \
	pulseaudio-module-udev-detect \
"
		


