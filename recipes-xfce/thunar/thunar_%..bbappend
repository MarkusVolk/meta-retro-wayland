PACKAGECONFIG_append += "pcre"

RRECOMMENDS_${PN} = " \
	thunar-archive-plugin \
	thunar-media-tags-plugin \
	thunar-shares-plugin \
"

