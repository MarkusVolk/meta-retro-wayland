DEPENDS += "python3-importlib-metadata"

