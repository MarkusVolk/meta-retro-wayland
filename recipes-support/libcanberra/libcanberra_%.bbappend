PACKAGECONFIG:remove = "gtk"

