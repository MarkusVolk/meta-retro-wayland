SUMMARY = "cowsay is a configurable talking cow"
HOMEPAGE = "https://github.com/piuccio/cowsay"
LICENSE = "MIT & ISC"
LIC_FILES_CHKSUM = "file://LICENSE;md5=113dd9a32921243b2e7f52052a3bfdb4 \
                    file://node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
                    file://node_modules/ansi-styles/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi/node_modules/is-fullwidth-code-point/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi/node_modules/string-width/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi/node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi/node_modules/strip-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/cliui/LICENSE.txt;md5=83623193d3051ca8068a89a455c699ca \
                    file://node_modules/cliui/node_modules/is-fullwidth-code-point/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/cliui/node_modules/string-width/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/cliui/node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/cliui/node_modules/strip-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/y18n/LICENSE;md5=55e5f88040679148136545002139a8b1 \
                    file://node_modules/get-stdin/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/emoji-regex/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
                    file://node_modules/p-limit/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/set-blocking/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
                    file://node_modules/decamelize/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/which-module/LICENSE;md5=42624e59bd3dabedcca59e1b54e3af50 \
                    file://node_modules/path-exists/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/locate-path/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/p-locate/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/camelcase/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/get-caller-file/LICENSE.md;md5=d21aa422a43e9693d50143d612b58967 \
                    file://node_modules/yargs-parser/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
                    file://node_modules/strip-final-newline/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/require-directory/LICENSE;md5=903997d26b12b72b43aa60018387bb90 \
                    file://node_modules/require-main-filename/LICENSE.txt;md5=8fd106383180f7bbb8f534414fdf7d35 \
                    file://node_modules/string-width/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/strip-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/yargs/LICENSE;md5=ec88e65c7bb01732069f3ad6b09ac90d \
                    file://node_modules/yargs/node_modules/is-fullwidth-code-point/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/yargs/node_modules/string-width/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/yargs/node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/yargs/node_modules/strip-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/p-try/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/find-up/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://package.json;md5=52dc16906d3798405e3aad2246c48f80 \
                    file://node_modules/ansi-regex/package.json;md5=d7acde142774ab8845b52b59dbab92d4 \
                    file://node_modules/ansi-styles/package.json;md5=ab7a71ab9f6b46acda83106c5f34e6e3 \
                    file://node_modules/camelcase/package.json;md5=31d66d63d07c9d3ab05757ac887e555b \
                    file://node_modules/cliui/node_modules/ansi-regex/package.json;md5=a23faa508e1750ce0af91a3f51c2053d \
                    file://node_modules/cliui/node_modules/is-fullwidth-code-point/package.json;md5=7c2dfa1f539b955d64d6af55282e1d9e \
                    file://node_modules/cliui/node_modules/string-width/package.json;md5=9546c3afdec6c3ee9a51fbb9d614976f \
                    file://node_modules/cliui/node_modules/strip-ansi/package.json;md5=6a0c65b4bd6c6b9cd068e2232eef50d9 \
                    file://node_modules/cliui/package.json;md5=7b96a725cd748174032a1ee492a1bef7 \
                    file://node_modules/color-convert/package.json;md5=370b0177fdb4368f0a688ffa48559ecf \
                    file://node_modules/color-name/package.json;md5=ef649e8b7be42bba6d4fa34aca7e126a \
                    file://node_modules/decamelize/package.json;md5=494b4faeb16e12979e988b49de7684d6 \
                    file://node_modules/emoji-regex/package.json;md5=57308bb3048f9db51fb79d3354f5a06f \
                    file://node_modules/find-up/package.json;md5=2beafc739bd0176c5dc63281986cde7d \
                    file://node_modules/get-caller-file/package.json;md5=1b4e6c1baf2c3673b9a7d1cc649ee66a \
                    file://node_modules/get-stdin/package.json;md5=02dc8f7727f6c10890152aa9128f3467 \
                    file://node_modules/is-fullwidth-code-point/package.json;md5=e199d7053a4c1508b8654c3965a58b20 \
                    file://node_modules/locate-path/package.json;md5=fe53da175b2ea65bd1708529b7437e87 \
                    file://node_modules/p-limit/package.json;md5=05ea6bd0b1f47d88b1328a020729de28 \
                    file://node_modules/p-locate/package.json;md5=f4bd5aebe35587fade4e331c175c4846 \
                    file://node_modules/p-try/package.json;md5=c3ec2260c0b640c43f15e99e4fa7b593 \
                    file://node_modules/path-exists/package.json;md5=99ba5e8952c0bb3471b6b1611a0fc534 \
                    file://node_modules/require-directory/package.json;md5=77d2cd39b67ccdf73bfc037d229cf0f8 \
                    file://node_modules/require-main-filename/package.json;md5=cb18c83a456ed5f4fdefcf20bbad4296 \
                    file://node_modules/set-blocking/package.json;md5=e37224b4c865b4464d6d41b1f8a870a4 \
                    file://node_modules/string-width/package.json;md5=9e0cb0da60820ee09789b5537fee5d81 \
                    file://node_modules/strip-ansi/package.json;md5=75c599f3b1853e4b8f25db1fb10881e1 \
                    file://node_modules/strip-final-newline/package.json;md5=df06cb6cb742b20108f5671ebbbf58a5 \
                    file://node_modules/which-module/package.json;md5=b4ab6a39c5e86263ade16635797218d2 \
                    file://node_modules/wrap-ansi/node_modules/ansi-regex/package.json;md5=a23faa508e1750ce0af91a3f51c2053d \
                    file://node_modules/wrap-ansi/node_modules/is-fullwidth-code-point/package.json;md5=7c2dfa1f539b955d64d6af55282e1d9e \
                    file://node_modules/wrap-ansi/node_modules/string-width/package.json;md5=9546c3afdec6c3ee9a51fbb9d614976f \
                    file://node_modules/wrap-ansi/node_modules/strip-ansi/package.json;md5=6a0c65b4bd6c6b9cd068e2232eef50d9 \
                    file://node_modules/wrap-ansi/package.json;md5=0bd9ef9e79c628202bf1edf7a38a8052 \
                    file://node_modules/y18n/package.json;md5=8257402a42ebdf07c8246fbd3bc7a312 \
                    file://node_modules/yargs/node_modules/ansi-regex/package.json;md5=a23faa508e1750ce0af91a3f51c2053d \
                    file://node_modules/yargs/node_modules/is-fullwidth-code-point/package.json;md5=7c2dfa1f539b955d64d6af55282e1d9e \
                    file://node_modules/yargs/node_modules/string-width/package.json;md5=9546c3afdec6c3ee9a51fbb9d614976f \
                    file://node_modules/yargs/node_modules/strip-ansi/package.json;md5=6a0c65b4bd6c6b9cd068e2232eef50d9 \
                    file://node_modules/yargs/package.json;md5=46ef436134f32cde79d1de2ac8a24558 \
                    file://node_modules/yargs-parser/package.json;md5=8b0c628b94396c7d183d1f184a5f4b93"

SRC_URI = " \
    npm://registry.npmjs.org/;package=cowsay;version=${PV} \
    npmsw://${THISDIR}/${BPN}/npm-shrinkwrap.json \
    "

S = "${WORKDIR}/npm"

RRECOMMENDS:${PN} = "fortune"

inherit npm

LICENSE:${PN} = "MIT"
LICENSE:${PN}-ansi-regex = "MIT"
LICENSE:${PN}-ansi-styles = "MIT"
LICENSE:${PN}-camelcase = "MIT"
LICENSE:${PN}-cliui-ansi-regex = "MIT"
LICENSE:${PN}-cliui-is-fullwidth-code-point = "MIT"
LICENSE:${PN}-cliui-string-width = "MIT"
LICENSE:${PN}-cliui-strip-ansi = "MIT"
LICENSE:${PN}-cliui = "ISC"
LICENSE:${PN}-color-convert = "MIT"
LICENSE:${PN}-color-name = "MIT"
LICENSE:${PN}-decamelize = "MIT"
LICENSE:${PN}-emoji-regex = "MIT"
LICENSE:${PN}-find-up = "MIT"
LICENSE:${PN}-get-caller-file = "ISC"
LICENSE:${PN}-get-stdin = "MIT"
LICENSE:${PN}-is-fullwidth-code-point = "MIT"
LICENSE:${PN}-locate-path = "MIT"
LICENSE:${PN}-p-limit = "MIT"
LICENSE:${PN}-p-locate = "MIT"
LICENSE:${PN}-p-try = "MIT"
LICENSE:${PN}-path-exists = "MIT"
LICENSE:${PN}-require-directory = "MIT"
LICENSE:${PN}-require-main-filename = "ISC"
LICENSE:${PN}-set-blocking = "ISC"
LICENSE:${PN}-string-width = "MIT"
LICENSE:${PN}-strip-ansi = "MIT"
LICENSE:${PN}-strip-final-newline = "MIT"
LICENSE:${PN}-which-module = "ISC"
LICENSE:${PN}-wrap-ansi-ansi-regex = "MIT"
LICENSE:${PN}-wrap-ansi-is-fullwidth-code-point = "MIT"
LICENSE:${PN}-wrap-ansi-string-width = "MIT"
LICENSE:${PN}-wrap-ansi-strip-ansi = "MIT"
LICENSE:${PN}-wrap-ansi = "MIT"
LICENSE:${PN}-y18n = "ISC"
LICENSE:${PN}-yargs-ansi-regex = "MIT"
LICENSE:${PN}-yargs-is-fullwidth-code-point = "MIT"
LICENSE:${PN}-yargs-string-width = "MIT"
LICENSE:${PN}-yargs-strip-ansi = "MIT"
LICENSE:${PN}-yargs = "MIT"
LICENSE:${PN}-yargs-parser = "ISC"
