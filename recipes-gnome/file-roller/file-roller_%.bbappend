
RRECOMMENDS_${PN} += " \
	zip \
	unzip \
	p7zip \
"

