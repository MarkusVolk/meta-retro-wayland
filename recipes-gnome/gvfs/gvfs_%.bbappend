
PACKAGECONFIG_append = " samba fuse"
