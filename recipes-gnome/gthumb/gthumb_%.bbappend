

DEPENDS:append = " libjxl libwebp"
