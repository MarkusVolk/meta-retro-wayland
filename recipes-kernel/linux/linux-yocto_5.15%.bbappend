FILESEXTRAPATHS:prepend := "${THISDIR}/5.15:"

SRC_URI:append = " \
    file://0001-nintendo-switch-driver.patch \
"

