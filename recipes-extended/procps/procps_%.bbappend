FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://sysctl.conf"

