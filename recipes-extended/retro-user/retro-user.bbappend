RETRO_USER_GROUPS_append = ",sudo,plugdev,shutdown"

