FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-autoname-workspaces.py-icon-configuration.patch"
