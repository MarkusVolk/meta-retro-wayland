# this patch gets pulled in by meta-rauc and doesn't apply anymore
SRC_URI_remove = "file://0001-mount-support-the-sizelimit-and-offset-option-for-lo.patch"
