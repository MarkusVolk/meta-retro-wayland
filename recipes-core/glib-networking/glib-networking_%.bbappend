PACKAGECONFIG:append = " gnutls"
