RRECOMMENDS_${PN} += " \
	dmenu-wayland \
	grim \
	imv \
	slurp \
	swaybg \
	waybar \
	wf-recorder \
"

