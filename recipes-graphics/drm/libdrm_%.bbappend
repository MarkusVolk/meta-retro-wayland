# use udev instead of mknod
PACKAGECONFIG_append_class-target = " udev"

