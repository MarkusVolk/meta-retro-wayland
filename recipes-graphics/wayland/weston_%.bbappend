PACKAGECONFIG[shell-kiosk] = "-Dshell-kiosk=true,-Dshell-kiosk=false"

PACKAGECONFIG:append = " pam kms egl webp shell-kiosk"
