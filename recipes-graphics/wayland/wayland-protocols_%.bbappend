DEPENDS += "wayland-native"

BBCLASSEXTEND = "native nativesdk"
