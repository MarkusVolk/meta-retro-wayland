FILESEXTRAPATHS_prepend := "${THISDIR}/xserver-xorg:"

SRC_URI_append = " file://0001-xwayland-Add-a-pkg-config-file-for-Xwayland.patch"

