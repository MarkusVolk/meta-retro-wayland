RDEPENDS:${PN} += "python3-pygobject python3-terminal"
