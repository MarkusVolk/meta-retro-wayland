FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += "file://0001-workaround-use_wayland.patch"
SRCREV = "dfed054455180c4f993a0114806d9c28913625b3"
