PACKAGECONFIG_append = " egl"

SRCREV = "${AUTOREV}"

